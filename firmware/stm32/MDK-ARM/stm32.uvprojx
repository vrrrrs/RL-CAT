# Keil uVision project stm32.uvprojx, settings and files
target stm32 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: stm32 +hex
  c flags: Optim=6 uC99=1 v6Lang=3 v6LangP=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\Core\Inc;  ..\Drivers\STM32F1xx_HAL_Driver\Inc;  ..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;  ..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;  ..\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Application/RL-CAT
    ../Core/Src/: rlca_crc16.c rlca_frame.c rlca_math.c rlca_phase.c rlca_sts.c app_main.c bsp_flash.c bsp_gpio.c bsp_shell.c bsp_softi2c.c bsp_tick.c bsp_uart.c servo_bus.c servo_port.c link_proto.c link_pi.c link_port.c battery.c battery_port.c imu.c imu_port.c rlca_safety.c rlca_calib_proc.c app_safety.c app_mode.c esp_fwd.c
software components: CMSIS:CORE 4.3.0
